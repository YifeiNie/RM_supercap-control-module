# Keil uVision project STM32F334_LED.uvprojx, settings and files
target STM32F334 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F334C8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F334
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F334x8,
  c include: ..\User;..\Libraries\CMSIS\Device\ST\STM32F30x\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F30x_StdPeriph_Driver\inc;..\User\led;..\User\hrtim;..\User\adc;..\User\delay;..\User\pid;..\User\control;..\User\filter;..\User\out_control;..\User\CAN;..\User\usart_new
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/arm/: startup_stm32f334x8.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F30x/Source/Templates/: system_stm32f30x.c
  group FirmLIB
    ../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_hrtim.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group USER
    ../User/: main.c stm32f3xx_it.c bsp_time.c
    ../User/delay/: delay.c
    ../User/led/: bsp_led.c
    ../User/adc/: bsp_adc.c
    ../User/hrtim/: bsp_hrtim.c
    ../User/pid/: bsp_pid.c
    ../User/control/: bsp_buck_control.c
    ../User/filter/: bsp_filter.c
    ../User/out_control/: bsp_out_control.c
    ../User/CAN/: bsp_can.c
    ../User/usart_new/: usart.c
